# Keil uVision project STM32HD.uvprojx, settings and files
target STM32F103RCT6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32HD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD
  c include: ..\SYSLIB;..\SYSTEM\DELAY;..\SYSTEM\KEY;..\SYSTEM\LED;..\SYSTEM\SYS;..\SYSTEM\TIMER;..\SYSTEM\USART;..\MQTT;..\FONT;..\SYSTEM\ESP8266;..\SYSTEM\DHT11;..\SYSTEM\LCD;..\SYSTEM\LED;..\SYSTEM\MLX90614
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/KEY/: key.c
    ../SYSTEM/LED/: led.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/TIMER/: timer.c
    ../SYSTEM/USART/: usart.c
    ../FONT/: font.c
    ../SYSTEM/ESP8266/: esp8266.c
    ../SYSTEM/LCD/: lcd.c
    ../SYSTEM/MLX90614/: MLX90614.c
  group USER
    ../USER/: main.c
  group SYSLIB
    ../SYSLIB/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
